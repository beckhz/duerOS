# IAR project baidu-ca.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MBED_CONF_MBED_CLIENT_SN_COAP_MAX_BLOCKWISE_PAYLOAD_SIZE=1024; MBEDTLS_CONFIG_FILE="baidu_ca_mbedtls_config.h"; DUER_DEBUG_LEVEL=3; DUER_MBEDTLS_DEBUG=0
  ICCARM.CCIncludePath2: ../../../libraries/mbedtls/include; ../../../libraries/mbed-client-c/nsdl-c; ../../../libraries/mbed-client-c/source/libCoap/src/include; ../../../libraries/mbed-client-c/source/libNsdl/src/include; ../../../libraries/mbed-trace; ../../../include; ../../../source; ../../../libraries/baidu_json
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: baidu-ca.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group baidu-json
    ../../../libraries/baidu_json/: baidu_json.c
  group mbed-client-c
    ../../../libraries/mbed-client-c/source/libCoap/src/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    ../../../libraries/mbed-client-c/source/libNsdl/src/: sn_grs.c sn_nsdl.c
  group mbedtls
    ../../../libraries/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group source
    ../../../source/: baidu_ca.c baidu_ca_coap.c baidu_ca_coap_ep.c baidu_ca_conf.c baidu_ca_debug.c baidu_ca_hashcode.c baidu_ca_mbedtrace.c baidu_ca_memory.c baidu_ca_mutex.c baidu_ca_ns_list.c baidu_ca_nsdl_adapter.c baidu_ca_random.c baidu_ca_timestamp.c baidu_ca_trans_encrypted.c baidu_ca_trans_wrapper.c baidu_ca_transport.c baidu_ca_util_network.c
